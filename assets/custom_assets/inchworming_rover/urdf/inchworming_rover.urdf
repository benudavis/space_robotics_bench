Commit message: finish adding custom env

File: assets/custom_assets/inchworming_rover/urdf/inchworming_rover.urdf (robot description, URDF)
Before this commit: robot inchworming_rover, 14 links, 13 joints
Links:
- removed link root
Joints:
- removed joint root_to_chassis
